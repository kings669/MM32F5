# Keil uVision project project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MM32F5277E9P MindMotion
  pack: MindMotion.MM32F5277E_DFP.0.0.5
  cpu: IRAM(0x30000000,0x1C000) IROM(0x08000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APP_SDSPI_BASIC NDEBUG BRD_PLUS_F5270
  c include: ../board;../device/drivers;..;../components/sdspi/src;../device/CMSIS/Include;../device;../application;..\components\ff14b\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x1c000
  scatter file: ../device/mdk/linker/mm32f5277e_flash.scf
  group application
    ../application/: main.c
  group board
    ../board/: board_init.c board_init.h clock_init.c clock_init.h pin_init.c pin_init.h sdspi_port.c
  group drivers
    ../device/drivers/: hal_adc.c hal_adc.h hal_common.h hal_comp.c hal_comp.h hal_crc.c hal_crc.h hal_dac.c hal_dac.h hal_dma.c hal_dma.h hal_dma_request.h hal_exti.c hal_exti.h hal_flexcan.c hal_flexcan.h hal_fsmc.c hal_fsmc.h hal_gpio.c hal_gpio.h hal_i2c.c hal_i2c.h hal_iwdg.c hal_iwdg.h hal_lptim.c hal_lptim.h hal_lpuart.c hal_lpuart.h hal_mds.c hal_mds.h hal_mds_remap.h hal_power.c hal_power.h hal_pwr.c hal_pwr.h hal_qspi.c hal_qspi.h hal_rcc.c hal_rcc.h hal_rtc.c hal_rtc.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_usb.c hal_usb.h hal_usb_bdt.h hal_wwdg.c hal_wwdg.h
  group device
    ../device/: hal_device_registers.h mm32f5277e.h mm32f5277e_features.h system_mm32f5277e.c system_mm32f5277e.h
    ../device/mdk/: startup_mm32f5277e.S
  group sdspi
    ../components/sdspi/src/: sdmmc_spec.h sdspi.h sdspi.c
  group ff14b
    ../components/ff14b/source/: diskio.c ff.c ffsystem.c ffunicode.c
